# Keil uVision project project.uvproj, settings and files
target STM32F429BIT6ZE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F439BI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User\app\fatfs_demo;..\..\User\usbd_mass_storage;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\User\framework\components\FatFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../../User/app/: main.c
  group bsp
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_timer.c bsp_uart_fifo.c bsp_ext_io.c bsp_nand_flash.c bsp_sdio_sd.c
    ../../User/bsp/: stm32f4xx_assert.c stm32f4xx_it.c bsp.c
  group stdPeriph_driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_fmc.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_sdio.c
  group cmsis
    ../../User/bsp/: system_stm32f4xx.c startup_stm32f429_439xx.s stm32f4xx.h system_stm32f4xx.h
  group framework
    ../../User/framework/components/FatFS/src/: diskio.c ff.c
    ../../User/framework/components/FatFS/src/option/: cc936.c
  group app
    ../../User/app/fatfs_demo/: demo_nand_fatfs.c
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp_stm32f4xx\inc;..\..\User\bsp_stm32f4xx;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
